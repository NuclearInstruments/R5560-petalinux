IMAGE_INSTALL_append = " libzmq"